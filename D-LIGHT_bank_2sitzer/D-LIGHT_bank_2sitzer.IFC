Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: D-LIGHT_bank_2sitzer.IFC
Time: 2015-10-13T20:11:30
Author: Test
Written by: SwIFC
Made in: SolidWorks 2016

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: Aufsatz-Linear austragen5
In: Default Storey
PredefinedType: ELEMENT; Material: 0
PSet_Type_Identity_Data - OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas

# IfcBuildingElementProxy: D-LIGHT_Polster_Bank_CAD_142
In: Default Storey
PredefinedType: ELEMENT; Material: 0
PSet_Type_Identity_Data - OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas
PSet_Mass_Property - Mass Measure: 133783; Area Measure: 3134643 m2; Volume Measure: 133782751 m3

# IfcBuildingElementProxy: Fläche löschen1
In: Default Storey
PredefinedType: ELEMENT; Material: 0
PSet_Type_Identity_Data - OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas

# IfcBuildingElementProxy: Fläche löschen2
In: Default Storey
PredefinedType: ELEMENT; Material: 0
PSet_Type_Identity_Data - OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas

# IfcBuildingElementProxy: Spiegeln1
In: Default Storey
PredefinedType: ELEMENT; Material: 0
PSet_Type_Identity_Data - OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas

# IfcBuildingElementProxy: Spiegeln2[2]
In: Default Storey
PredefinedType: ELEMENT; Material: 0
PSet_Type_Identity_Data - OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas
