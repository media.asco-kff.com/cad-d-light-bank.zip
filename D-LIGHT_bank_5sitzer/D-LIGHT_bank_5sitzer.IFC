Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: D-LIGHT_bank_5sitzer.IFC
Time: 2015-10-13T20:18:18
Author: Test
Written by: SwIFC
Made in: SolidWorks 2016

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: Austragung1
In: Default Storey
PredefinedType: ELEMENT; Material: 0
PSet_Type_Identity_Data - OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas

# IfcBuildingElementProxy: D-LIGHT_Bank_Mittelkufe_cad
In: Default Storey
PredefinedType: ELEMENT; Material: 0
PSet_Type_Identity_Data - OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas

# IfcBuildingElementProxy: D-LIGHT_Polster_Bank_CAD_292
In: Default Storey
PredefinedType: ELEMENT; Material: 0
PSet_Type_Identity_Data - OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas
PSet_Mass_Property - Mass Measure: 296147; Area Measure: 6463790 m2; Volume Measure: 296146523 m3

# IfcBuildingElementProxy: Körper-Verschieben/Kopieren1[1]
In: Default Storey
PredefinedType: ELEMENT; Material: 0
PSet_Type_Identity_Data - OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas

# IfcBuildingElementProxy: Körper-Verschieben/Kopieren1[2]
In: Default Storey
PredefinedType: ELEMENT; Material: 0
PSet_Type_Identity_Data - OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas

# IfcBuildingElementProxy: Spiegeln1[1]
In: Default Storey
PredefinedType: ELEMENT; Material: 0
PSet_Type_Identity_Data - OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas
